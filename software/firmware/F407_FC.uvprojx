# Keil uVision project F407_FC.uvprojx, settings and files
target OmniBotHub_Core (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STMF405_CORE +hex
  AfterMake: fromelf --bin !L --output TEST.ANO
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6LangP=3 v6Lto=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: .\applications;.\build;.\drivers;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\DSP_LIB\Include;.\Libraries\CMSIS\ST\STM32F4xx\Include;.\Libraries\USBStack\INC;.\Libraries\FatFS\src;.\Libraries\CMSIS\Include;.\MAVLINK;.\MAVLINK\minimal;.\USB\STM32_USB_Device_Library\Core\inc;.\USB\STM32_USB_HOST_Library\Core\inc;.\USB\STM32_USB_OTG_Driver\inc;.\USB\USB_APP;..\HARDWARE\USB\STM32_USB_Device_Library\Class\cdc\inc;.\USB\STM32_USB_Device_Library\Class\cdc\inc;.\DSP_LIB\Include;.\DSP_LIB\;.\CMSIS\Include;.\SCSs;.\OLED\;.\OLED\OLED;.\OLED\Config;.\OLED\Fonts;.\OLED\GUI;.\OLED\Example;.\OLDE_v1;.\quadruped_src;.\system_src;.\balance_controller;.\applications;.\estimator_sr
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group System
    ./quadruped_src/: include.h
    ./applications/: main.c scheduler.c init.c stm32f4xx_it.c
    ./system_src/: sys.c delay.c
  group Drivers
    ./drivers/: Custom_SPI_Device.c spi.c flash.c flash_w25.c time.c bat.c beep.c dma.c gps.c led_fc.c pwm_out.c watch_dog.c wsled_l.c sbus_oldx.lib
  group Libraries
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_rng.c stm32f4xx_can.c stm32f4xx_iwdg.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Math&Fushion
    ./balance_controller/: gait_math.h common_math.c kin_math.c RT_math.c fliter_math.c
    ./estimator_sr/: baro_fushion.c baro_kf.c EKF_AHRS.c EKF_UPDATE.c pose_fushion.c pose_kf.c rt_nonfinite.c rtGetInf.c rtGetNaN.c baro_ekf_oldx.lib cycle_cal_oldx.lib
    ./quadruped_src/: rng.c eso.c
    ./DSP_LIB/: arm_cortexM4lf_math.lib
  group Motor_Link
    ./drivers/: mit_link.c ecos_link1.c
    ./balance_controller/: base_struct.h locomotion_header.h
  group Communication
    ./drivers/: i2c_soft.c usart_fc.c can.c
    ./USB/USB_APP/: usbd_cdc_vcp.c usb_bsp.c usbd_desc.c usbd_usr.c
    ./USB/STM32_USB_Device_Library/Core/src/: usbd_ioreq.c usbd_req.c usbd_core.c
    ./USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
    ./USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group Sensor
    ./quadruped_src/: imu.c mems.c
    ./drivers/: outter_hml.c icm20602.c ms5611.c aoa_uwb.c nlink_utils.c
  group Mavlink
    ./MAVLINK/minimal/: mavlink_msg_ahrs.c mavlink_msg_attitude.c mavlink_msg_global_position_int.c mavlink_msg_gps_raw_int.c mavlink_msg_gps_status.c mavlink_msg_heartbeat.c mavlink_msg_hwstatus.c mavlink_msg_limits_status.c mavlink_msg_meminfo.c mavlink_msg_mission_current.c mavlink_msg_mission_request.c mavlink_msg_nav_controller_output.c mavlink_msg_param_value.c mavlink_msg_raw_imu.c mavlink_msg_rc_channels_raw.c mavlink_msg_rc_channels_scaled.c mavlink_msg_sensor_offsets.c mavlink_msg_servo_output_raw.c mavlink_msg_simstate.c mavlink_msg_statustext.c mavlink_msg_sys_status.c mavlink_msg_vfr_hud.c testsuite.c
    ./MAVLINK/: mavlink_helpers.c fifo.c mavl.c checksum.c protocol.c
  group Servos
    ./SCSs/: SCS.c SCSCL.c SCSerail.c SMS_STS.c
  group OLED
    ./OLED/Example/: OLED_0in91_test.c ImageData.c
    ./OLED/OLED/: OLED_0in91.c
    ./OLED/Fonts/: font12.c
    ./OLED/GUI/: GUI_Paint.c
software components: CMSIS:CORE 6.1.1, Compiler:I/O:STDOUT 1.2.0
