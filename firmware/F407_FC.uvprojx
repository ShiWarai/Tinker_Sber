# Keil uVision project F407_FC.uvprojx, settings and files
target OmniBotHub_Core (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STMF405_CORE +hex
  AfterMake: fromelf --bin !L --output .\build\OmniBotHub_Core.bin
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6LangP=3 v6Lto=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: .\include;.\include\app;.\include\drivers;.\include\math;.\include\sensors;.\include\servos;.\include\system;.\build;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\DSP_LIB\Include;.\Libraries\CMSIS\ST\STM32F4xx\Include;.\Libraries\FatFS\src;.\Libraries\CMSIS\Include;.\DSP_LIB\Include;.\DSP_LIB\;.\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group System
    ./include/: include.h
    ./src/app/: main.c scheduler.c init.c stm32f4xx_it.c
    ./src/system/: sys.c delay.c
  group Drivers
    ./src/drivers/: Custom_SPI_Device.c spi.c flash.c flash_w25.c time.c bat.c beep.c dma.c led_fc.c pwm_out.c watch_dog.c wsled_l.c
  group Libraries
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_rng.c stm32f4xx_can.c stm32f4xx_iwdg.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Math&Fushion
    ./include/math/: gait_math.h
    ./src/drivers/: rng.c
    ./src/math/: common_math.c RT_math.c fliter_math.c
    ./DSP_LIB/: arm_cortexM4lf_math.lib
  group Motor_Link
    ./src/drivers/: mit_link.c
    ./include/math/: base_struct.h
  group Communication
    ./src/drivers/: usart_fc.c can.c
  group Sensor
    ./src/sensors/: imu.c mems.c
    ./src/drivers/: icm20602.c
  group Servos
    ./src/servos/: SCS.c SCSCL.c SCSerail.c SMS_STS.c
software components: CMSIS:CORE 6.1.1, Compiler:I/O:STDOUT 1.2.0
